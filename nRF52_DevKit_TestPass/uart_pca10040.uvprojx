# Keil uVision project uart_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\Origin_SDK\config;..\..\Origin_SDK\components;..\..\Origin_SDK\components\boards;..\..\Origin_SDK\components\drivers_nrf\nrf_soc_nosd;..\..\Origin_SDK\components\libraries\atomic;..\Origin_SDK\components\libraries\balloc;..\Origin_SDK\components\libraries\bsp;..\Origin_SDK\components\libraries\delay;..\Origin_SDK\components\libraries\experimental_section_vars;..\Origin_SDK\components\libraries\fifo;..\Origin_SDK\components\libraries\log;..\Origin_SDK\components\libraries\log\src;..\Origin_SDK\components\libraries\memobj;..\Origin_SDK\components\libraries\ringbuf;..\Origin_SDK\components\libraries\strerror;..\Origin_SDK\components\libraries\uart;..\Origin_SDK\components\libraries\util;..\Origin_SDK\..;..\Origin_SDK\external\fprintf;..\Origin_SDK\integration\nrfx;..\Origin_SDK\integration\nrfx\legacy;..\Origin_SDK\modules\nrfx;..\Origin_SDK\modules\nrfx\drivers\include;..\Origin_SDK\modules\nrfx\hal;..\Origin_SDK\modules\nrfx\mdk;.\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress 6330
  group Application
    ./src/: main.c
    ./config/: sdk_config.h
  group Board Definition
    ../../Origin_SDK/components/boards/: boards.c
  group nRF_Drivers
    ../Origin_SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../Origin_SDK/modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c
    ../../Origin_SDK/integration/nrfx/legacy/: nrf_drv_uart.c
  group nRF_Libraries
    ../Origin_SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../Origin_SDK/components/libraries/fifo/: app_fifo.c
    ../Origin_SDK/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../Origin_SDK/components/libraries/atomic/: nrf_atomic.c
    ../Origin_SDK/components/libraries/balloc/: nrf_balloc.c
    ../Origin_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../Origin_SDK/components/libraries/memobj/: nrf_memobj.c
    ../Origin_SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../Origin_SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../Origin_SDK/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
